Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: W LUM-F 43.1577.6600.IFC
Time: 2023-11-03T10:04:37
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBeam: W LUM-F 43.1577.6600
In: Default Storey
SolidWorks Custom Properties - Description: PWR(43W);LUM.FLUX(6600lm)
PSet_Mass_Property - Mass Measure: 13.9673; Area Measure: 0.609383 m2; Volume Measure: 4.24425e-314
