Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: W LUM-F 33.1277.5000.IFC
Time: 2023-11-03T10:02:11
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBeam: W LUM-F 33.1277.5000
In: Default Storey
SolidWorks Custom Properties - Description: PWR(33W);LUM.FLUX(5000lm)
PSet_Mass_Property - Mass Measure: 0; Area Measure: 0.406036 m2; Volume Measure: 0.00789084 m3
